## base_external/packages/lcd-driver/Config.in
```kconfig
config BR2_PACKAGE_LCD_DRIVER
	bool "lcd-driver"
	help
	  includes the lcd linux module driver
```
